# IAR project uTaskerBoot.ewp, settings and files
configuration uTaskerBoot - Flash (ARM)
  General.OGChipSelectEditMenu: STM32F746IE ST STM32F746IE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: _STM32; _COMPILE_IAR
  ICCARM.CCIncludePath2: .; ..\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uTaskerBoot.bin
  ILINK.IlinkOutputFile: uTaskerBoot.out
  ILINK.IlinkIcfFile: C:\MJBC\Repositories\uTasker-Kinetis\Applications\uTaskerBoot\IAR9_STM32\settings\STM32_F7_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: config.h types.h uTaskerBootLoader.c
  group Hardware
    ../../../Hardware/STM32/: STM32_boot.c
