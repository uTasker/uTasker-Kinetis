# Keil uVision project uTaskerBoot.uvprojx, settings and files
target uTaskerBootLoader (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: uTaskerBoot +hex
  AfterMake: Make-Binary.bat
  c flags: Optim=4
  c define: _COMPILE_KEIL, _KINETIS
  c include: ..\
  asm define: CORTEX_M0
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: settings/KL_128_16.sct
  link misc: --entry main
--keep=reset_vect
--keep=__flash_config
  group Source Files
    ../: uTaskerBootLoader.c
  group Hardware
    ../../../Hardware/Kinetis/: kinetis_asm.s kinetis_boot.c
