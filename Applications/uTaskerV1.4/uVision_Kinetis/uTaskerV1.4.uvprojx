# Keil uVision project uTaskerV1.4.uvprojx, settings and files
target uTaskerV1.4 (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: uTaskerV1_4 +hex
  AfterMake: Make-Binary.bat
  c flags: Optim=4
  c define: _COMPILE_KEIL, _KINETIS
  c include: ..\
  asm define: CORTEX_M0
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: settings/KL_128_16.sct
  link misc: --entry main
--keep=reset_vect
--keep=__flash_config
  group uTasker
    ../../../uTasker/: can_drv.c Driver.c eth_drv.c GlobalTimer.c iic_drv.c low_power.c SSC_drv.c Tty_drv.c uFile.c uMalloc.c uNetwork.c USB_drv.c uTasker.c Watchdog.c time_keeper.c
  group TCP/IP
    ../../../stack/: arp.c dhcp.c dns.c Ethernet.c ftp.c http.c icmp.c ip.c ip_utils.c NetBIOS.c pop3.c ppp.c smtp.c snmp.c tcp.c telnet.c tftp.c udp.c webutils.c zero_config.c ftp_client.c igmp.c
  group Source Files
    ../: application.c debug.c KeyScan.c modbus_app.c NetworkIndicator.c usb_application.c webInterface.c snmp_mib_handlers.c FreeMaster.c nRF24201.c
  group Header Files
    ../: ADC_Timers.h app_hw_kinetis.h app_user_files.h application.h application_lcd.h can_tests.h config.h iic_tests.h Port_Interrupts.h TaskConfig.h types.h user_glcd_fonts.h widgets.h
    ../../../stack/: tcpip.h
  group Hardware
    ../../../Hardware/Kinetis/: kinetis.c kinetis.h kinetis_asm.s
  group utFAT
    ../../../uTasker/utFAT/: mass_storage.c mass_storage.h NAND_driver.h
  group MODBUS
    ../../../uTasker/MODBUS/: MODBUS.c modbus.h
  group uGLCDLIB
    ../../../uTasker/uGLCDLIB/: GLCD.c glcd.h glcd_cglcd.h glcd_fonts.h glcd_nokia.h glcd_oled.h glcd_samsung.h glcd_tft.h glcd_toshiba.h LCD.c
target uTaskerV1.4-BM (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.0
  cpu: as above
  output: uTaskerV1_4_BM +hex
  AfterMake: Make-Binary-BM.bat
  c flags: Optim=4
  c define: _COMPILE_KEIL, _KINETIS
  c include: ..\
  asm define: CORTEX_M0
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: settings/KL_128_16_BM.sct
  link misc: --entry main
--keep=reset_vect
