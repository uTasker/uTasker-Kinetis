# IAR project uTaskerV1.4.ewp, settings and files
configuration Flash (ARM)
  General.OGChipSelectEditMenu: MK20DN128xxx5 NXP MK20DN128xxx5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: _KINETIS; _COMPILE_IAR
  ICCARM.CCIncludePath2: .; ..\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uTaskerV1.4.bin
  ILINK.IlinkOutputFile: uTaskerV1.4.out
  ILINK.IlinkIcfFile: settings\K_128_16.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.FPU2: 4
  ICCARM.CCDefines: _COMPILE_IAR; _KINETIS
  ICCARM.CCOptLevel: 2
  OBJCOPY.OOCOutputFile: uTaskerV1.4.srec
  ILINK.IlinkIcfFile: settings\K_128.icf
configuration Flash_BM (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.FPU2: 4
  ICCARM.CCOptLevel: 2
  OBJCOPY.OOCOutputFile: uTaskerV1.4_BM.bin
  ILINK.IlinkOutputFile: uTaskerV1.4_BM.out
  ILINK.IlinkIcfFile: settings\K_1M_256_BM.icf
  group (top)
    ../: application.c debug.c KeyScan.c modbus_app.c NetworkIndicator.c snmp_mib_handlers.c usb_application.c webInterface.c
  group Hardware
    ../../../Hardware/Kinetis/: kinetis.c
  group TCP/IP
    ../../../stack/: arp.c dhcp.c dns.c Ethernet.c ftp.c ftp_client.c http.c icmp.c igmp.c ip.c ip_utils.c NetBIOS.c pop3.c ppp.c smtp.c snmp.c tcp.c tcpip.h telnet.c tftp.c udp.c webutils.c zero_config.c
  group uTasker
    ../../../uTasker/: can_drv.c Driver.c eth_drv.c GlobalTimer.c iic_drv.c low_power.c SSC_drv.c time_keeper.c Tty_drv.c uFile.c uMalloc.c uNetwork.c USB_drv.c uTasker.c Watchdog.c
  group uTasker/MODBUS
    ../../../uTasker/MODBUS/: MODBUS.c modbus.h
  group uTasker/uGLCDLIB
    ../../../uTasker/uGLCDLIB/: GLCD.c glcd.h glcd_cglcd.h glcd_fonts.h glcd_nokia.h glcd_oled.h glcd_samsung.h glcd_tft.h glcd_toshiba.h LCD.c
  group uTasker/utFAT
    ../../../uTasker/utFAT/: mass_storage.c mass_storage.h NAND_driver.h
